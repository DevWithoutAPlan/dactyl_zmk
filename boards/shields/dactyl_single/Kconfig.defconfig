## boards/shields/dactyl_single/Kconfig.defconfig
```kconfig
if SHIELD_DACTYL_SINGLE

config ZMK_KEYBOARD_NAME
    default "dactyl_single"

endif # SHIELD_DACTYL_SINGLE
```
